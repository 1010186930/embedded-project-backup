# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_USB_OTG_FS
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DOTDRIVER;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\DOTPROCESSOR;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\NAND;..\MALLOC;..\HARDWARE\UTFTOUNI;..\HARDWARE\TRANSLATE;..\HARDWARE\SEGMENT;..\TEXT;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\USB_APP;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\CSK4002
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_nand.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/DOTDRIVER/: dot_driver.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DOTPROCESSOR/: dot_processor.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: ltdc.c lcd.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
    ../HARDWARE/TRANSLATE/: translate.c
    ../HARDWARE/UTFTOUNI/: touni.c
    ../HARDWARE/SEGMENT/: segment.c
    ../HARDWARE/CSK4002/: csk4002.c
  group MALLOC
    ../MALLOC/: malloc.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
