# IAR project USBH_MSC.ewp, settings and files
configuration STM324xG-EVAL_USBH-HS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc; ..\..\..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\..\Utilities\STM32F4-Discovery; ..\..\..\..\..\..\Utilities\fat_fs\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.bin
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBH-HS.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324xG-EVAL_USBH-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; USE_USB_OTG_FS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBH-FS.out
  group App
    ../src/: main.c stm32fxxx_it.c usb_bsp.c usbh_usr_lcd.c
  group FAT_FS
    ../../../../../../Utilities/fat_fs/src/: fattime.c ff.c
  group STM32F4-Discovery
    ../../../../../../Utilities/STM32F4-Discovery/: lcd_log.c stm32f4_discovery.c stm32f4_discovery_lcd.c
  group STM32F4xx
    ../../../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USB_Host/Class/MSC
    ../../../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Host/Core
    ../../../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../../../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
