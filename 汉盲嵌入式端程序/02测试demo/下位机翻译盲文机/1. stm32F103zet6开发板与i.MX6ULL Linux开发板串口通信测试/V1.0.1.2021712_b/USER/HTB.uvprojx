# Keil uVision project HTB.uvprojx, settings and files
target HTB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HZ +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\SD;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\SDIO;..\TEXT;..\HARDWARE\W25QXX;..\HARDWARE\SUOCUN;..\MALLOC;..\HARDWARE\HTPTB;..\HARDWARE\TTS;..\HARDWARE\TIMER;..\HARDWARE\WKUP;..\HARDWARE\StringProcess;..\HARDWARE\BrailleUSART;..\HARDWARE\BrailleProtocol;..\HARDWARE\UTFTOUNI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SUOCUN/: suocun.c
    ../HARDWARE/HTPTB/: htptb.c
    ../HARDWARE/TTS/: TTS.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/StringProcess/: StringProcess.c
    ../HARDWARE/BrailleProtocol/: BrailleProtocol.c
    ../HARDWARE/BrailleUSART/: BrailleUSART.c
    ../HARDWARE/UTFTOUNI/: touni.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_pwr.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c mycc936.c
  group README
    ../: README.TXT
  group TEXT
    ../TEXT/: fontupd.c text.c
